# Keil uVision project SimpleDemo.uvproj, settings and files
target N9H20K5_NAND_480x272 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: 2onprog
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: fromelf.exe --bin --output "$P../Bin/@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __480x272__
  c include: ..\..\..\..\Driver\Include;..\..\..\..\ThirdParty\emWin\Config;..\..\..\..\ThirdParty\emWin\Include;..\Application;..\tslib
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group Src
    ../: main.c wb_init.s standalone.c
  group Lib
    ../../../../Library/IPLib/: N9H20_SYS.lib N9H20_VPOST_GIANTPLUS_GPM1006D.lib N9H20_VPOST_FW050TFT_800x480.lib N9H20_VPOST_FW043TFT_480x272.lib N9H20_ADC.lib N9H20_SIC.lib N9H20_BLT.lib N9H20_JPEG.lib N9H20_KPI_2x3.lib N9H20_GPIO.lib N9H20_SPU.lib
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
    ../../../../Library/NVTFATLib/: N9H20_NVTFAT.lib
  group tslib
    ../tslib/: ts_calibrate.c N9H20TouchPanel.c N9H20TouchPanel.h
  group GUI_Config
    ../../../../ThirdParty/emWin/Config/: LCDConf.c GUI_X.c GUIConf.c
  group GUI_Lib
    ../../../../ThirdParty/emWin/Lib/: NUemWin_ARM9_Keil.lib
  group Application
    ../Application/: f0.c f1.c f2.c f3.c f4.c f5.c f6.c f7.c f8.c f9.c u00.c u01.c u02.c u03.c u04.c u05.c u06.c u07.c u08.c u09.c u10.c u11.c u12.c u13.c u14.c u15.c u16.c u17.c u18.c u19.c u20.c u21.c u22.c u23.c u24.c u25.c u26.c u27.c u28.c u29.c u30.c u31.c u32.c u33.c u34.c d00.c d01.c d02.c d03.c d04.c d05.c d06.c d07.c d08.c d09.c d10.c d11.c d12.c d13.c d14.c d15.c d16.c d17.c d18.c d19.c d20.c d21.c d22.c d23.c d24.c d25.c d26.c d27.c d28.c d29.c d30.c d31.c d32.c d33.c d34.c c.c o.c
  group App
    ../Application/: GUIConf.c LCDConf.c NVT_Config.c
