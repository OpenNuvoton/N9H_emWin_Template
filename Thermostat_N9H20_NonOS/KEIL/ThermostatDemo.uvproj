# Keil uVision project ThermostatDemo.uvproj, settings and files
target N9H20K5_NAND_480x480 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: conprog
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: fromelf.exe --bin --output "$P../Bin/@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEMO_INIT_BY_DRIVER__=0 NVT_WIFI=0
  c include: ..\..\..\..\Driver\Include;..\..\..\..\ThirdParty\emWin\Config;..\..\..\..\ThirdParty\emWin\Include;..\Touch;..\Lcd;..\Modbus_Master;..\Application;..\Application\Heading;..\Application\Menu1;..\Application\Menu2;..\Application\Menu3;..\Application\Common;..\Application\Font;..\Tuya_IoT
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
  group Src
    ../: main.c wb_init.s standalone.c
  group Application
    ../Application/: Thermostat.c
  group Lcd
    ../Lcd/: N9H20_VPOST_D395T9375V0_480x480.lib LCDConf1.c LCDConf2.c GUIConf2.c N9H20_EFFECT.lib
  group Touch
    ../Touch/: FT6336.h N9H20TouchPanel.h N9H20TouchPanel.c
  group Modbus_Master
    ../Modbus_Master/: RS485_UART.c ModbusMaster.c ModbusMaster.h def.h word.h crc16.h
  group Lib
    ../../../../Library/IPLib/: N9H20_SYS.lib N9H20_BLT.lib N9H20_JPEG.lib N9H20_EDMA.lib N9H20_GPIO.lib N9H20_I2C.lib N9H20_RTC.lib N9H20_SIC.lib N9H20_PWM.lib
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
    ../../../../Library/NVTFATLib/: N9H20_NVTFAT.lib
  group GUI_Config
    ../../../../ThirdParty/emWin/Config/: LCDConf.c GUI_X.c GUIConf.c
  group GUI_Lib
    ../../../../ThirdParty/emWin/Lib/: NUemWin_ARM9_Keil.lib
  group Heading
    ../Application/Heading/: logo.c
  group Menu1
    ../Application/Menu1/: menu1.c menu1up1.c menu1down1.c menu1back1.c dehumidify1.c dehumidify1disable1.c fan1.c fan1disable1.c cool1.c cool1disable1.c heat1.c heat1disable1.c
  group Menu2
    ../Application/Menu2/: menu2.c menu2up1.c menu2down1.c menu2back1.c
  group Menu3
    ../Application/Menu3/: menu3.c menu3back1.c
  group Common
    ../Application/Common/: onoffselect1.c on1.c off1.c
  group Tuya_IoT
    ../Tuya_IoT/: mcu_api.h protocol.h system.h wifi.h TUYA_IoT.lib
