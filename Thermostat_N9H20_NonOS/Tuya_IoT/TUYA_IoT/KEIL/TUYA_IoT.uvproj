# Keil uVision project TUYA_IoT.uvproj, settings and files
target DebugRel (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: TUYA_IoT (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\Library\IPLib
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../: mcu_api.c mcu_api.h protocol.c protocol.h system.c system.h wifi.h
