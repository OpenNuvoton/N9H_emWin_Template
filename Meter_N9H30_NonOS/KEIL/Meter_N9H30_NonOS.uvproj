# Keil uVision project Meter_N9H30_NonOS.uvproj, settings and files
target Meter_N9H30_NonOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: Meter_N9H30_NonOS
  AfterMake: fromelf --bin ".\obj\@L.axf" --output "..\bin\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __USE_SD__ _PANEL_FW070TFT_24BPP_
  c include: ..\..\..\Driver\Source;..\..\..\Driver\Include;..\..\..\ThirdParty\FATFS\src;..\..\..\ThirdParty\emWin\Config;..\..\..\ThirdParty\emWin\Include;..\..\emWin_SimpleDemo;..\tslib;..\Application
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H30.sct
  link misc: --entry 0
  group Application
    ../Application/: GUIDEMO.c Images.c LCDConf2.c
  group Libraries
    ../../../Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c gpio.c sdh.c lcd.c adc.c system_N9H30.c startup_N9H30.s sys_N9H30.s spi.c 2d.c jpegcodec.c uart.c
  group FatFs
    ../../../ThirdParty/FATFS/src/: ff.c
  group tslib
    ../tslib/: fbutils.c testutils.c TouchPanel.c ts_calibrate.c diskio.c SDGlue.c spilib.c
  group emWin
    ../../../ThirdParty/emWin/Config/: GUI_X.c GUIConf.c LCDConf.c
    ../../../ThirdParty/emWin/Lib/: NUemWin_ARM9_Keil.lib
  group src
    ../: main.c
