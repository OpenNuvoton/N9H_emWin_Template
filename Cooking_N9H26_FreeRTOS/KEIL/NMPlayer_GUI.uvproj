# Keil uVision project NMPlayer_GUI.uvproj, settings and files
target NMPlayer_GUI_SD_WVGA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: conprog
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: fromelf.exe --bin --output "$P../Bin/@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __N9H26__ STORAGE_SD __800x480__
  c misc: --c99
  c include: ..\..\..\BSP\N9H26_emWin_NonOS\BSP\Driver\Include;..\..\..\BSP\N9H26_emWin_NonOS\BSP\ThirdParty\emWin\Include;..\..\..\ThirdParty\POSIX_FreeRTOS\include;..\..\..\ThirdParty\POSIX_FreeRTOS\POSIX\include;..\..\..\ThirdParty\POSIX_FreeRTOS\Portable\N9H26\ARMCC;..\..\..\ThirdParty\POSIX_FreeRTOS\FreeRTOS\Source\include;..\..\..\ThirdParty\POSIX_FreeRTOS\POSIX\include\portable;..\..\..\ThirdParty\POSIX_FreeRTOS\include\private;..\..\..\Package\NVTMedia\inc;..\..\..\ThirdParty\tiny-regex-c;..\inc
  asm define: N9H26K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\BSP\N9H26_emWin_NonOS\BSP\Script\N9H26\N9H26K5.sct
  link misc: --entry 0
  group Startup
    ../src/StartUp/: main.c wb_init.s standalone.c multithread.c Retarget.c
  group Application
    ../src/Application/: PlaybackDLG.c TaskGUIDemo.c TaskTouching.c Player.c PCMPlayback.c Render.c FileList.c Window_CookingDLG.c PNGLib.lib Window_TempDLG.c Window_SettingDLG.c NVT_Config.c NVT_Config.h NVT_Playback1.c NVT_Setting1.c NVT_Temp1.c NVT_Cooking1.c
  group NVTMedia
    ../../../PrebuildLib/N9H26/ARMCC/: POSIX_FreeRTOS.lib N9H26_AACDecoder.lib ImgProc.lib NVTMedia.lib
    ../../../Package/NVTMedia/src/SAL/: NVTMedia_SAL_FS.c
  group GUI_Config
    ../src/GUI_Config/: LCDConf.c GUI_X.c GUIConf.c
  group re
    ../../../ThirdParty/tiny-regex-c/: re.c
  group tslib
    ../src/tslib/: fbutils.c N9H26TouchPanel.c testutils.c ts_calibrate.c
  group Lib
    ../../../BSP/N9H26_emWin_NonOS/BSP/Library/IPLib/: N9H26_VPOST_FW050TFT_800x480.lib N9H26_GIANTPLUS_GPM1006D.lib N9H26_ADC.lib N9H26_SIC.lib N9H26_BLT.lib N9H26_JPEG.lib N9H26_SYS_FreeRTOS.lib N9H26_AAC.lib N9H26_GPIO.lib N9H26_VPE.lib N9H26_SPU.lib
    ../../../BSP/N9H26_emWin_NonOS/BSP/Library/GNANDLib/: N9H26_GNAND.lib
    ../../../BSP/N9H26_emWin_NonOS/BSP/ThirdParty/emWin/Lib/: NUemWin_ARM9_Keil.lib
    ../../../PrebuildLib/N9H26/ARMCC/: N9H26_H264CodecFreeRTOS.lib N9H26_NVTFAT_FREERTOS_1B.lib
