# Keil uVision project SimpleDemo.uvproj, settings and files
target N9H20K5_NAND_480x272 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: conprog
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: fromelf.exe --bin --output "$P../Bin/@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __480x272__
  c include: ..\..\..\..\Driver\Include;..\..\..\..\ThirdParty\emWin\Config;..\..\..\..\ThirdParty\emWin\Include;..\Application;..\tslib
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group Src
    ../: main.c wb_init.s standalone.c
  group Lib
    ../../../../Library/IPLib/: N9H20_SYS.lib N9H20_VPOST_GIANTPLUS_GPM1006D.lib N9H20_VPOST_FW050TFT_800x480.lib N9H20_VPOST_FW043TFT_480x272.lib N9H20_ADC.lib N9H20_SIC.lib N9H20_BLT.lib N9H20_JPEG.lib N9H20_EDMA.lib
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
    ../../../../Library/NVTFATLib/: N9H20_NVTFAT.lib
  group tslib
    ../tslib/: fbutils.c ts_calibrate.c testutils.c N9H20TouchPanel.c N9H20TouchPanel.h
  group GUI_Config
    ../../../../ThirdParty/emWin/Config/: LCDConf.c GUI_X.c GUIConf.c GUIConf.h
    ../Application/: GUIConf2.c LCDConf2.c
  group GUI_Lib
    ../../../../ThirdParty/emWin/Lib/: NUemWin_ARM9_Keil.lib
  group Application
    ../Application/: NVT_Config.h NVT_Config.c Main1DLG.c NVT_Main1.c Setting1DLG.c NVT_Setting1.c Freezer1DLG.c NVT_Freezer1.c GUIDEMO_Graph.c
